# Repository lthimx/pnpbox1

File README.md:

<h1 align="center">MagnetCnC 3</h1>

This is a prototype for pick and place, smd soldering but also laser cutting/engraving.
The head and the moving arm of the prototype will be design to be modular and magnetic (No screwing is neeeded to change/upgrade the head or arm).

## Visual overview
This is a visual overview of what the prototype does... for the moment, because it will does more "usecool" things like soldering and laser engraving or cutting.

## Global view of the prototype

## Buttons
This is a view of two buttons for reset and unlock operations but it can be re-configured for others actions.

## Pnpbox1 
This is an overview of the prototype box which contains all the mains components, the pump too ! .

## DB25 pinout
This is the pinout of the two DB25 connectors on the Pnpbox

## Inside the pnpboxV1.0.1 prototype: Global view

## KiCad design PCBs/left_magnet_arm/up/interface_up_left_side_arm/interface_up_left_side_arm.kicad_pcb

File PCBs/README.md:

# DuinoPnP v1
Here are the kicad files for the prototype shield for the machine, it is designed with the arduino-uno form factor, i call it the "duinoPnP"

## v1.0.1 3D viewer

Global 3D view of V1.0.1 PCB

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10: LED; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
J1: DB25_Female; DSUB-25_Female_Vertical_P2.77x2.84mm_MountingHoles
J2, J3: Conn_02x07_Odd_Even; PinHeader_2x07_P2.54mm_Vertical
J4: Conn_01x04_Female; JST_EH_B4B-EH-A_1x04_P2.50mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10: R; R_0805_2012Metric

Connections:
1: J1.1, J3.12
2: J1.2, J3.10
3: J1.3, J3.8, R9.1
4: J1.4, J3.6
5: J1.5, J3.4, R10.1
8: J1.8, J3.11
9: J1.9, J3.9
10: J1.10, J3.7
11: J1.11, J3.5
12: J1.12, J3.3, R4.1
13: J1.13, J3.1, R2.1
14: J1.14, J3.14, R8.1
15: J1.15
19: J1.19, J2.7
20: J1.20, J2.5
21: J1.21, J2.3, R5.1
22: J1.22, J2.1
+3V3: J1.17, J1.18, J2.9, J2.11, R3.1
+12V: J1.16, J1.23, J1.24, J1.25, J2.2, J2.4, J2.6, J2.13, R1.1
GND: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), J1.6, J1.7, J3.2, J3.13
M1: J2.8, J4.1, R6.1
M2: J2.10, J4.2
M3: J2.12, J4.3
M4: J2.14, J4.4, R7.1
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2
unnamed: D4.2 (A), R4.2
unnamed: D5.2 (A), R5.2
unnamed: D6.2 (A), R6.2
unnamed: D7.2 (A), R7.2
unnamed: D8.2 (A), R8.2
unnamed: D9.2 (A), R9.2
unnamed: D10.2 (A), R10.2

Board: 2 copper layers, 30.0 x 90.0 mm, 24 parts (2 on the bottom side), 33 nets.

## KiCad design PCBs/pnpbox1_pcb_main/pnpbox1_pcb_main/pnpbox1_pcb_main.kicad_pcb

Parts:
C1, C2, C3, C4: 100uF; C_Radial_D5.0mm_H11.0mm_P2.00mm
MP1584EN_DC-DC1: Conn_01x08; MP1584EN convertisseur DC-DC
MSA1: MSA; PinHeader_2x03_P2.54mm_Vertical
MSX1: MSX; PinHeader_2x03_P2.54mm_Vertical
MSY1: MSY; PinHeader_2x03_P2.54mm_Vertical
MSZ1: MSZ; PinHeader_2x03_P2.54mm_Vertical
P8: 12V-36V; BarrelJack_Horizontal
P10: power switch; JST_EH_B2B-EH-A_1x02_P2.50mm_Vertical
Pled1: yellow; LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm
Pump1: pump; JST_EH_B2B-EH-A_1x02_P2.50mm_Vertical
Q0: IRF630; TO-220-3_Horizontal_TabDown
R1, R2, R3, R4: 100K; R_0805
R5: 10K; R_0805
R6: 10K; R_0805_2012Metric
R7: 1K; R_0805_2012Metric
Rp1: Rp; R_0805_2012Metric
Rpwr1: Rpwr; R_0805_2012Metric
Rpwr_1: Rpwr_; R_0805_2012Metric
RstpA1: RstpA; R_0805_2012Metric
RstpX1: RstpX; R_0805_2012Metric
RstpY1: RstpY; R_0805_2012Metric
RstpZ1: RstpZ; R_0805_2012Metric
SW1: RESET; SWITCH_TACTILE_6.5_PTH
U1: ARDUINO_UNO_SHIELD/hi five revb; ARDUINO_SHIELD
U2: X; POLOLU_STEPPER_DRIVER
U3: Y; POLOLU_STEPPER_DRIVER
U4: Z; POLOLU_STEPPER_DRIVER
U5: A; POLOLU_STEPPER_DRIVER
V_led1: red; LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm
Vled1: green; LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm
conn26_0: 0; IDC-Header_2x13_P2.54mm_Vertical
conn26_1: 1; IDC-Header_2x13_P2.54mm_Vertical
l_pwr1: Conn_01x02; JST_EH_B2B-EH-A_1x02_P2.50mm_Vertical
ledA1: blue; LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm
ledX1: blue; LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm
ledY1: blue; LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm
ledZ1: white; LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm
pi_5V1: Conn_01x02; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal

Connections:
5V_pi: MP1584EN_DC-DC1.5, MP1584EN_DC-DC1.6, pi_5V1.2
+3V3: U1.27 (3V3)
+5V: MSA1.1, MSA1.3, MSA1.5, MSX1.1, MSX1.3, MSX1.5, MSY1.1, MSY1.3, MSY1.5, MSZ1.1, MSZ1.3, MSZ1.5, R5.1, U1.26 (5V), U2.10 (VDD), U3.10 (VDD), U4.10 (VDD), U5.10 (VDD), conn26_1.1, conn26_1.5
/G: Q0.2 (G), R6.1, R7.2
ADIR: U1.14 (D13), U5.8 (DIR)
ASTEP: RstpA1.1, U1.12 (D11), U5.7 (STEP), conn26_0.13
B_led: U1.20 (A2), conn26_0.23
B_sig: U1.17 (A5), conn26_0.15
D: Pump1.2, Q0.1 (D), Rp1.1
DC: U1.1 (D0/RX), conn26_1.6
EN: R5.2, U1.9 (D8), U2.1 (EN), U3.1 (EN), U4.1 (EN), U5.1 (EN)
GND: MP1584EN_DC-DC1.1, MP1584EN_DC-DC1.2, MP1584EN_DC-DC1.7, MP1584EN_DC-DC1.8, Pled1.1 (K), Q0.3 (S), R1.2, R2.2, R3.2, R4.2, R6.2, SW1.1, SW1.2, U1.15 (GND), U1.24 (GND), U1.25 (GND), U2.9 (GND), U3.9 (GND), U4.9 (GND), U5.9 (GND), V_led1.1 (K), Vled1.1 (K), conn26_0.2, conn26_0.4, conn26_0.6, conn26_0.8, conn26_0.10, conn26_0.12, conn26_0.14, conn26_0.16, conn26_0.18, conn26_0.20, conn26_0.22, conn26_0.24, conn26_0.26, conn26_1.2, conn26_1.8, l_pwr1.1, ledA1.1 (K), ledX1.1 (K), ledY1.1 (K), ledZ1.1 (K), pi_5V1.1
GNDA: C1.2, C2.2, C3.2, C4.2, P8.2, P8.3, U2.15 (GND), U3.15 (GND), U4.15 (GND), U5.15 (GND)
unnamed: MSA1.2, R4.1, U5.2 (MS1)
unnamed: MSA1.4, U5.3 (MS2)
unnamed: MSA1.6, U5.4 (MS3)
unnamed: MSX1.2, R1.1, U2.2 (MS1)
unnamed: MSX1.4, U2.3 (MS2)
unnamed: MSX1.6, U2.4 (MS3)
unnamed: MSY1.2, R2.1, U3.2 (MS1)
unnamed: MSY1.4, U3.3 (MS2)
unnamed: MSY1.6, U3.4 (MS3)
unnamed: MSZ1.2, R3.1, U4.2 (MS1)
unnamed: MSZ1.4, U4.3 (MS2)
unnamed: MSZ1.6, U4.4 (MS3)
unnamed: Pled1.2 (A), Rp1.2
unnamed: Rpwr1.2, Vled1.2 (A)
unnamed: Rpwr_1.2, V_led1.2 (A)
unnamed: RstpA1.2, ledA1.2 (A)
unnamed: RstpX1.2, ledX1.2 (A)
unnamed: RstpY1.2, ledY1.2 (A)
unnamed: RstpZ1.2, ledZ1.2 (A)
unnamed: U2.5 (RST), U2.6 (SLP)
unnamed: U3.5 (RST), U3.6 (SLP)
unnamed: U4.5 (RST), U4.6 (SLP)
unnamed: U5.5 (RST), U5.6 (SLP)
O_led: U1.22 (A0), conn26_0.19
O_sig: U1.21 (A1), conn26_0.21
RESET: SW1.3, SW1.4, U1.28 (RESET), conn26_0.25
VIN: C1.1, C2.1, C3.1, C4.1, MP1584EN_DC-DC1.3, MP1584EN_DC-DC1.4, P10.1, Pump1.1, Rpwr1.1, U2.16 (VMOT), U3.16 (VMOT), U4.16 (VMOT), U5.16 (VMOT), l_pwr1.2
VIN_: P8.1, P10.2, Rpwr_1.1
XDIR: U1.6 (D5), U2.8 (DIR)
XLIMIT: U1.10 (D9), conn26_0.9, conn26_0.11
XSTEP: RstpX1.1, U1.3 (D2), U2.7 (STEP)
YDIR: U1.7 (D6), U3.8 (DIR)
YLIMIT: U1.11 (D10), conn26_0.5, conn26_0.7
YSTEP: RstpY1.1, U1.4 (D3), U3.7 (STEP)
ZDIR: U1.8 (D7), U4.8 (DIR)
ZLIMIT: U1.13 (D12), conn26_0.1, conn26_0.3
ZSTEP: RstpZ1.1, U1.5 (D4), U4.7 (STEP)
_SCL_: U1.30 (_SCL_), conn26_1.3
_SDA_: U1.29 (_SDA_), conn26_1.4
a1A: U5.12 (1A), conn26_1.21
a1B: U5.11 (1B), conn26_1.23
a2A: U5.13 (2A), conn26_1.19
a2B: U5.14 (2B), conn26_1.17
pump_ctrl: R7.1, U1.18 (A4)
res: U1.2 (D1/TX), conn26_1.7
up_light: U1.19 (A3), conn26_0.17
x1A: U2.12 (1A), conn26_1.14
x1B: U2.11 (1B), conn26_1.16
x2A: U2.13 (2A), conn26_1.12
x2B: U2.14 (2B), conn26_1.10
y1A: U3.12 (1A), conn26_1.13
y1B: U3.11 (1B), conn26_1.15
y2A: U3.13 (2A), conn26_1.11
y2B: U3.14 (2B), conn26_1.9
z1A: U4.12 (1A), conn26_1.22
z1B: U4.11 (1B), conn26_1.24
z2A: U4.13 (2A), conn26_1.20
z2B: U4.14 (2B), conn26_1.18

Board: 2 copper layers, 69.1 x 76.3 mm, 44 parts (0 on the bottom side), 70 nets.

## KiCad design PCBs/fixed_head_pcb/fixed_head_pcb/fixed_head_pcb.kicad_pcb

Parts:
J1, J2, J3: Conn_01x05; JST_EH_B5B-EH-A_1x05_P2.50mm_Vertical
U1: Pick_and_place_pcb; fixed_head_PCB_v1.0

Connections:
+3V3: J1.1, U1.11
+12V: J2.5, U1.5
A1A: J2.1, U1.1
A1B: J2.3, U1.3
A2A: J2.2, U1.2
A2B: J2.4, U1.4
GND: J3.4, U1.9
SCL: J3.2, U1.7
SDA: J3.1, U1.6
Z1A: J1.5, U1.15
Z1B: J1.3, U1.13
Z2A: J1.4, U1.14
Z2B: J1.2, U1.12
limZ: J3.3, U1.8
pwm: J3.5, U1.10

Board: 2 copper layers, 60.0 x 36.1 mm, 4 parts (0 on the bottom side), 15 nets.

## KiCad design PCBs/reset_button/reset_button/reset_button.kicad_pcb

Parts:
J1: Conn_01x05; JST_EH_B5B-EH-A_1x05_P2.50mm_Vertical
SW1, SW2: SW_DIP_x02; reset_button

Connections:
B_led: J1.1, SW1.1
B_sig: J1.2, SW1.2
GND: J1.5, SW1.3, SW1.4, SW2.3, SW2.4
O_led: J1.4, SW2.1
O_sig: J1.3, SW2.2

Board: 2 copper layers, 40.0 x 20.0 mm, 3 parts (0 on the bottom side), 5 nets.

## KiCad design PCBs/pick_n_place_head/pick_n_place_head/pick_n_place_head.kicad_pcb

Parts:
Amot1: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
M1, M2, M3: magnet_conn_X5
R1, R2: R; R_0805_2012Metric
U1: 24AA02-OT; SOT-23-5
Zmot1: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
blue1: LED; LED_1206_3216Metric
green1: LED; LED_1206_3216Metric

Connections:
+3V3: M1.5, R2.1, U1.4 (VCC)
+12V: M3.1, R1.1
A1A: Amot1.1, M3.5
A1B: Amot1.3, M3.3
A2A: Amot1.2, M3.4
A2B: Amot1.4, M3.2
GND: M2.4, U1.2 (GND), blue1.1 (K), green1.1 (K)
unnamed: R1.2, blue1.2 (A)
unnamed: R2.2, green1.2 (A)
SCL: M2.2, U1.1 (SCL)
SDA: M2.1, U1.3 (SDA)
Z1A: M1.1, Zmot1.1
Z1B: M1.3, Zmot1.3
Z2A: M1.2, Zmot1.2
Z2B: M1.4, Zmot1.4
limZ: M2.3
pwm: M2.5

Board: 2 copper layers, 63.2 x 43.1 mm, 10 parts (0 on the bottom side), 15 nets.

## KiCad design PCBs/pick_and_place_PCB_2/pick_n_place_pcb_2/pick_n_place_pcb_2/pick_n_place_pcb_2.kicad_pcb

Parts:
D1, D2: LED; LED_1206_3216Metric
J1, J2: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
R1, R2: R; R_0805_2012Metric
U1: Pick_and_place_pcb; PnP_PCB_v1.0
U2: 24AA02-OT; SOT-23-5

Connections:
+3V3: R2.1, U1.11, U2.4 (VCC)
+12V: R1.1, U1.5
A1A: J1.1, U1.1
A1B: J1.3, U1.3
A2A: J1.2, U1.2
A2B: J1.4, U1.4
GND: D1.1 (K), D2.1 (K), U1.9, U2.2 (GND)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
SCL: U1.7, U2.1 (SCL)
SDA: U1.6, U2.3 (SDA)
Z1A: J2.1, U1.15
Z1B: J2.3, U1.13
Z2A: J2.2, U1.14
Z2B: J2.4, U1.12
limZ: U1.8
pwm: U1.10

Board: 2 copper layers, 63.2 x 43.1 mm, 8 parts (0 on the bottom side), 15 nets.
