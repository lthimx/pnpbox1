# Repository lthimx/pnpbox1 (continued)

## KiCad design mdified-sb-cnc-shield-master/sb-cnc-shield.kicad_pcb

Parts:
C1, C2, C3, C4: 100uF; c_elec_6.3x7.7
JP1, JP2, JP3, JP4, JP5, JP6, JP7, JP8, JP9, JP10, JP11, JP12, JP32, JP33, JP34, JP35, JP36, JP37, JP38, JP39: Jumper_NO_Small; Pin_100mil_Header_Straight_1x02
JP13: Z+; Pin_100mil_Header_Straight_1x02
JP14: Z-; Pin_100mil_Header_Straight_1x02
JP15: Y+; Pin_100mil_Header_Straight_1x02
JP16: Y-; Pin_100mil_Header_Straight_1x02
JP17: X+; Pin_100mil_Header_Straight_1x02
JP18: X-; Pin_100mil_Header_Straight_1x02
JP19: SpinEn; Pin_100mil_Header_Straight_1x02
JP20: SpinDir; Pin_100mil_Header_Straight_1x02
JP21: CoolEn; Pin_100mil_Header_Straight_1x02
JP22: Abort; Pin_100mil_Header_Straight_1x02
JP23: Hold; Pin_100mil_Header_Straight_1x02
JP24: Resume; Pin_100mil_Header_Straight_1x02
JP25: ESTOP; Pin_100mil_Header_Straight_1x02
JP26: EN/GND; Pin_100mil_Header_Straight_1x02
JP27: XSTEP/DIR; Pin_100mil_Header_Straight_1x02
JP28: YSTEP/DIR; Pin_100mil_Header_Straight_1x02
JP29: ZSTEP/DIR; Pin_100mil_Header_Straight_1x02
JP30: ASTEP/DIR; Pin_100mil_Header_Straight_1x02
JP31: +5V/GND; Pin_100mil_Header_Straight_1x02
P1: XMOT; Pin_Header_Straight_2x04
P2: YMOT; Pin_Header_Straight_2x04
P3: ZMOT; Pin_Header_Straight_2x04
P4: AMOT; Pin_Header_Straight_2x04
P5: UART; Pin_Header_Straight_1x04
P6: I2C; Pin_Header_Straight_1x04
P7: ES_SETUP; Pin_Header_Straight_1x03
P8: 12V-36V; BarrelJack_Horizontal
R1, R2, R3, R4: 100K; R_0805
R5: 10K; R_0805
SW1: RESET; SWITCH_TACTILE_6.5_PTH
U1: ARDUINO_UNO_SHIELD; ARDUINO_SHIELD
U2: X; POLOLU_STEPPER_DRIVER
U3: Y; POLOLU_STEPPER_DRIVER
U4: Z; POLOLU_STEPPER_DRIVER
U5: A; POLOLU_STEPPER_DRIVER

Connections:
+3V3: P5.1, U1.27 (3V3)
+5V: JP1.1, JP2.1, JP3.1, JP4.1, JP5.1, JP6.1, JP7.1, JP8.1, JP9.1, JP10.1, JP11.1, JP12.1, JP31.1, P5.2, P7.1, R5.1, U1.26 (5V), U2.10 (VDD), U3.10 (VDD), U4.10 (VDD), U5.10 (VDD)
ABORT: JP22.2, U1.22 (A0)
ADIR: JP30.2, JP36.2, JP37.2, JP38.2, JP39.2, U5.8 (DIR)
ASTEP: JP30.1, JP32.2, JP33.2, JP34.2, JP35.2, U5.7 (STEP)
COOLANT: JP21.2, U1.19 (A3)
EN: JP26.1, R5.2, U1.9 (D8), U2.1 (EN), U3.1 (EN), U4.1 (EN), U5.1 (EN)
EN_SETUP: JP13.1, JP14.1, JP15.1, JP16.1, JP17.1, JP18.1, P7.2
GND: JP19.1, JP20.1, JP21.1, JP22.1, JP23.1, JP24.1, JP25.1, JP26.2, JP31.2, P6.2, P7.3, R1.2, R2.2, R3.2, R4.2, SW1.1, SW1.2, U1.15 (GND), U1.24 (GND), U1.25 (GND), U2.9 (GND), U3.9 (GND), U4.9 (GND), U5.9 (GND)
GNDA: C1.2, C2.2, C3.2, C4.2, P8.2, P8.3, U2.15 (GND), U3.15 (GND), U4.15 (GND), U5.15 (GND)
HOLD: JP23.2, U1.21 (A1)
unnamed: JP1.2, R1.1, U2.2 (MS1)
unnamed: JP2.2, U2.3 (MS2)
unnamed: JP3.2, U2.4 (MS3)
unnamed: JP4.2, R2.1, U3.2 (MS1)
unnamed: JP5.2, U3.3 (MS2)
unnamed: JP6.2, U3.4 (MS3)
unnamed: JP7.2, R3.1, U4.2 (MS1)
unnamed: JP8.2, U4.3 (MS2)
unnamed: JP9.2, U4.4 (MS3)
unnamed: JP10.2, R4.1, U5.2 (MS1)
unnamed: JP11.2, U5.3 (MS2)
unnamed: JP12.2, U5.4 (MS3)
unnamed: P1.1, U2.14 (2B)
unnamed: P1.2, U2.13 (2A)
unnamed: P1.3, U2.12 (1A)
unnamed: P1.4, U2.11 (1B)
unnamed: P2.1, U3.14 (2B)
unnamed: P2.2, U3.13 (2A)
unnamed: P2.3, U3.12 (1A)
unnamed: P2.4, U3.11 (1B)
unnamed: P3.1, U4.14 (2B)
unnamed: P3.2, U4.13 (2A)
unnamed: P3.3, U4.12 (1A)
unnamed: P3.4, U4.11 (1B)
unnamed: P4.1, U5.14 (2B)
unnamed: P4.2, U5.13 (2A)
unnamed: P4.3, U5.12 (1A)
unnamed: P4.4, U5.11 (1B)
unnamed: U2.5 (RST), U2.6 (SLP)
unnamed: U3.5 (RST), U3.6 (SLP)
unnamed: U4.5 (RST), U4.6 (SLP)
unnamed: U5.5 (RST), U5.6 (SLP)
RESET: JP25.2, P6.1, SW1.3, SW1.4, U1.28 (RESET)
RESUME: JP24.2, U1.20 (A2)
RX: P5.4, U1.1 (D0/RX)
SCL: P6.4, U1.17 (A5)
SDA: P6.3, U1.18 (A4)
SPIN_DIR: JP20.2, JP39.1, U1.14 (D13)
SPIN_EN: JP19.2, JP35.1, U1.12 (D11)
TX: P5.3, U1.2 (D1/TX)
VIN: C1.1, C2.1, C3.1, C4.1, P8.1, U2.16 (VMOT), U3.16 (VMOT), U4.16 (VMOT), U5.16 (VMOT)
XDIR: JP27.2, JP36.1, U1.6 (D5), U2.8 (DIR)
XLIMIT: JP17.2, JP18.2, U1.10 (D9)
XSTEP: JP27.1, JP32.1, U1.3 (D2), U2.7 (STEP)
YDIR: JP28.2, JP37.1, U1.7 (D6), U3.8 (DIR)
YLIMIT: JP15.2, JP16.2, U1.11 (D10)
YSTEP: JP28.1, JP33.1, U1.4 (D3), U3.7 (STEP)
ZDIR: JP29.2, JP38.1, U1.8 (D7), U4.8 (DIR)
ZLIMIT: JP13.2, JP14.2, U1.13 (D12)
ZSTEP: JP29.1, JP34.1, U1.5 (D4), U4.7 (STEP)

Board: 2 copper layers, 68.6 x 53.3 mm, 62 parts (0 on the bottom side), 61 nets.

## Commit log

2021-09-20 modifié : main.c
2021-09-21 add helloMan
2021-09-22 enable M7 command for pump control
2021-09-26 use 'abort' GPIO for orange button led
2021-10-03 add openpnp directory
2021-10-03 create 'code' dorectory
2021-10-03 add freecad and kicad
2021-10-03 modified directory structure and change arduino path for lib and main
2021-10-03 disable Z homing
2021-10-04 disable lock at reset or boot
2021-10-04 add rst_on and rst_off functions
2021-10-05 program homing after reset or boot
2021-10-10 remove homing after reset and add openpnp cfg
2021-10-22 add jack barrel for power supply in kicad
2021-10-22 add jack barrel for power supply in kicad, correction
2021-10-22 modify jack barrel position for power supply in kicad
2021-10-22 modify the 4 capacitors foorprint and rotate MS1/2/3 connector
2021-10-22 modify name
2021-10-22 connect GNDs and connect the e-stop for reset
2021-10-22 rename directory to PCBs directory
2021-10-22 modify name PCBs
2021-10-22 add _SDC_ _SCL_ for hi five rev b board
2021-10-22 add power button, lenghten pcb
2021-10-24 add pump management circuit, I2C JST conn for display, JST power switch
2021-10-25 add voltage regulator shield for 5V rpi
2021-10-31 modify kicad and create gerbers then ordering PCBs on JLPCB
2021-11-01 remove README in PCBs
2021-11-16 add hifive rev b code
2021-11-17 add sifive-hifive1-revb-pnpbox1
2021-11-17 add images
2021-11-17 modify gif
2021-11-17 add gif
2021-11-17 modify readme and add some images
2021-11-17 modify readme and add some images 2
2021-11-17 add readme for programming stepper motor, basis
2021-11-17 rename
2021-11-17 add kicad image
2021-11-17 add readme in freecad dir
2021-11-20 add some functions to be ported
2021-11-20 correct grammar
2021-11-20 find the name of the machine
2021-11-20 logo
2021-11-24 modify hifive1_revb devicetree to adescribe a little flash partition
2021-11-25 zephyrproject reinit
2021-11-25 README minor update. modified: README.md
2021-12-04 correct z1A pinoutgit add .!
2021-12-04 add DB25 pinout
2021-12-05 pinout modify
2021-12-05 modify pinout
2021-12-05 add 3Dview of PCB
2021-12-05 add protoViewV1.0.1
2021-12-05 correct pinout
2021-12-05 change pnpbox photo
2021-12-10 modify arduino code to switch D12 adn D11 digital pin (Astep to Zlim)
2022-01-20 add main-head-mobile freecad
2022-01-29 update freecad design
2022-03-08 modify kicad and freecad
2022-03-26 add acrylic cut and other freecad design
2022-04-11 modification
